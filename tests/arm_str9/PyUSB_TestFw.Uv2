### uVision2 Project, (C) Keil Software
### Do not modify !

Target (PyUSB Test Firmware), 0x0004 // Tools: 'ARM-ADS'

Group (Startup)
Group (Application)
Group (ST Library)
Group (USB Library)

File 1,2,<.\src\STR91x.s><STR91x.s>
File 2,1,<.\src\ring_buffer.c><ring_buffer.c>
File 2,1,<.\src\main.c><main.c>
File 2,1,<.\src\util.c><util.c>
File 2,1,<.\src\91x_it.c><91x_it.c>
File 2,1,<.\src\usb_pwr.c><usb_pwr.c>
File 2,1,<.\src\usb_desc.c><usb_desc.c>
File 2,1,<.\src\usb_endp.c><usb_endp.c>
File 2,1,<.\src\usb_istr.c><usb_istr.c>
File 2,1,<.\src\usb_prop.c><usb_prop.c>
File 3,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\91x_scu.c><91x_scu.c>
File 3,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\91x_vic.c><91x_vic.c>
File 3,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\91x_ahbapb.c><91x_ahbapb.c>
File 3,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\91x_fmi.c><91x_fmi.c>
File 4,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\USB\usb_regs.c><usb_regs.c>
File 4,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\USB\usb_core.c><usb_core.c>
File 4,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\USB\usb_init.c><usb_init.c>
File 4,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\USB\usb_int.c><usb_int.c>
File 4,1,<C:\Keil\ARM\RV31\LIB\ST\STR91x\USB\usb_mem.c><usb_mem.c>


Options 1,0,0  // Target 'PyUSB Test Firmware'
 Device (STR912FW44)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM9E))
 FlashUt ()
 StupF ("STARTUP\ST\STR91x.s" ("STR91x Startup Code"))
 FlashDR (UL2ARM(-UU0639C7E -O15 -S0 -C1 -N00("ST uPSD Flash") -D00(04570041) -L00(8) -N01("ARM966E-S Core") -D01(25966041) -L01(4) -N02("ST Boundary Scan") -D02(0457F041) -L02(5) -FO15 -FD4000000 -FC800 -FN2 -FF0STR91xFxx4 -FS00 -FL080000 -FF1STR91xB1 -FS1400000 -FL18000))
 DevID (4067)
 Rgf (91x_lib.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ÿST\91x\)
 TgStat=16
 OutDir (.\OBJ\)
 OutName (PyUSB_TestFw)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=1
 Browse=0
 LstDir (.\LST\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 ADSFLGA { 243,31,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACPUTYP (ARM9E)
 RVDEV ()
 ADSTFLGA { 0,12,32,16,163,0,1,66,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSIRAM { 0,0,0,0,4,0,128,1,0 }
 OCMADSIROM { 1,0,0,0,0,0,0,8,0 }
 OCMADSXRAM { 0,0,0,0,0,0,0,0,0 }
 OCR_RVCT { 1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,8,0,1,0,0,64,0,0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,4,0,128,1,0,0,0,0,0,0,0,0,0,0 }
 RV_STAVEC ()
 ADSCCFLG { 4,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSCMISC ()
 ADSCDEFN ()
 ADSCUDEF ()
 ADSCINCD (C:\Keil\ARM\INC\ST\91x\USB)
 ADSASFLG { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSAMISC ()
 ADSADEFN ()
 ADSAUDEF ()
 ADSAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ADSLDFG { 17,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSLDTA ()
 ADSLDDA ()
 ADSLDSC ()
 ADSLDIB ()
 ADSLDIC ()
 ADSLDMC ()
 ADSLDIF ()
 ADSLDDW ()
  OPTDL (SARM.DLL)(-cSTR91x)(DARMST9.DLL)(-pSTR912)(SARM.DLL)(-cSTR91x)(TARMST9.DLL)(-pSTR912)
  OPTDBG 48125,-1,()()()()()()()()()() ()()()()
 FLASH1 { 1,0,0,0,1,0,0,0,0,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2ARM.DLL)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

